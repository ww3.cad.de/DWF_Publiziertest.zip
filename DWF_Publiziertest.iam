# Autodesk Inventor assembly: DWF_Publiziertest
## iProperties
Created: 2007-11
Part Number: DWF_Publiziertest
Document SubType Name: Assembly
Designer: thomas
Author: thomas
